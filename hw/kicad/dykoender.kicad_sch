File: hw/kicad/dykoender.kicad_sch (KiCad schematic)
At the start: 0 parts

Commit message: mcu
Other:
- added sheet mcu (mcu.kicad_sch)
